# Keil uVision project Project_T9_2023.uvprojx, settings and files
target User (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_T9_2023
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;.\src;.\fatfs\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ./inc/: RFID_RC522.h spi.h tim.h usart.h main.h
  group src
    ./src/: spi.c RFID_RC522.c tim.c usart.c main.c
  group fatfs
    ./fatfs/Inc/: diskio.h fatfs.h fatfs_sd_card.h ff.h ff_gen_drv.h ffconf.h integer.h user_diskio.h
    ./fatfs/Src/: ccsbcs.c diskio.c fatfs.c fatfs_sd_card.c ff.c ff_gen_drv.c syscall.c user_diskio.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
